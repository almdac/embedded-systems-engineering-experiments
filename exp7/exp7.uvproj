# Keil uVision project exp7.uvproj, settings and files
target Target 1 (MCS-51)
  device: SAB 80C517A Infineon
  cpu: IRAM(0-0xFF) CLOCK(18000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: exp7
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: exp7.c
